<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>run_RootMUSIC_calib_lin_array_X310_TwinRX</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_calibration_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value13</key><value>"calibration_lin_array_245.cfg"</value></param>
<param><key>value2</key><value>2450000000</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value11</key><value>"/tmp"</value></param>
<param><key>field0</key><value>ToneFreq</value></param>
<param><key>field1</key><value>SampleRate</value></param>
<param><key>field10</key><value>PSpectrumLength</value></param>
<param><key>field11</key><value>DirectoryConfigFiles</value></param>
<param><key>field12</key><value>RelativePhaseOffsets</value></param>
<param><key>field13</key><value>AntennaCalibration</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>RxAddr</value></param>
<param><key>field4</key><value>Gain</value></param>
<param><key>field5</key><value>NumArrayElements</value></param>
<param><key>field6</key><value>NormSpacing</value></param>
<param><key>field7</key><value>SnapshotSize</value></param>
<param><key>field8</key><value>OverlapSize</value></param>
<param><key>field9</key><value>NumTargets</value></param>
<param><key>value4</key><value>60</value></param>
<param><key>value6</key><value>0.5</value></param>
<param><key>value5</key><value>2</value></param>
<param><key>value9</key><value>1</value></param>
<param><key>value8</key><value>2**9</value></param>
<param><key>value10</key><value>2**10</value></param>
<param><key>value12</key><value>"measure_X310_TwinRX_relative_phase_offsets_245.cfg"</value></param>
<param><key>value3</key><value>"addr=192.168.10.2"</value></param>
<param><key>value1</key><value>1000000</value></param>
<param><key>value7</key><value>2**11</value></param>
<param><key>value0</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_phase_offsets_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)</value></param>
</block>
<block>
<key>doa_antenna_correction</key>
<param><key>id</key><value>doa_antenna_correction_0</value></param>
<param><key>config_filename</key><value>antenna_calibration_file_name</value></param>
<param><key>num_inputs</key><value>input_variables.NumArrayElements</value></param>
</block>
<block>
<key>doa_autocorrelate</key>
<param><key>id</key><value>doa_autocorrelate_0</value></param>
<param><key>avg_method</key><value>1</value></param>
<param><key>inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>overlap_size</key><value>input_variables.OverlapSize</value></param>
<param><key>snapshot_size</key><value>input_variables.SnapshotSize</value></param>
</block>
<block>
<key>doa_qt_compass</key>
<param><key>id</key><value>doa_qt_compass_0</value></param>
<param><key>arc_bias</key><value>0</value></param>
<param><key>max_val</key><value>180</value></param>
<param><key>min_val</key><value>0</value></param>
<param><key>name</key><value>""</value></param>
<param><key>step</key><value>10</value></param>
<param><key>update_time</key><value>0.10</value></param>
</block>
<block>
<key>doa_rootMUSIC_linear_array</key>
<param><key>id</key><value>doa_rootMUSIC_linear_array_0</value></param>
<param><key>norm_spacing</key><value>input_variables.NormSpacing</value></param>
<param><key>inputs</key><value>input_variables.NumArrayElements</value></param>
<param><key>num_targets</key><value>input_variables.NumTargets</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>phase_correct_hier</key>
<param><key>id</key><value>phase_correct_hier_1</value></param>
<param><key>config_filename</key><value>rel_phase_offsets_file_name</value></param>
<param><key>num_ports</key><value>input_variables.NumArrayElements</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Pseudo-Spectrum</value></param>
<param><key>label1</key><value>Angle of Arrival (MUSIC)</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>twinrx_usrp_source</key>
<param><key>id</key><value>twinrx_usrp_source_0</value></param>
<param><key>center_freq</key><value>input_variables.CenterFreq</value></param>
<param><key>addresses</key><value>input_variables.RxAddr</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>input_variables.Gain</value></param>
<param><key>sources</key><value>input_variables.NumArrayElements</value></param>
<param><key>samp_rate</key><value>input_variables.SampleRate</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>input_variables.CenterFreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>input_variables.Gain</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>input_variables.CenterFreq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>input_variables.Gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>input_variables.SampleRate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>doa_antenna_correction_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_antenna_correction_0</source_block_id><sink_block_id>doa_autocorrelate_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doa_autocorrelate_0</source_block_id><sink_block_id>doa_rootMUSIC_linear_array_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_rootMUSIC_linear_array_0</source_block_id><sink_block_id>doa_qt_compass_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_antenna_correction_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>doa_antenna_correction_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
